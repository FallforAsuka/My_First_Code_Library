# Keil uVision project STM32C8.uvproj, settings and files
target STM32 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103RC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM32C8 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USART1_IN_IRQ,TIM4_IN_IRQ,USE_STDPERIPH_DRIVER, STM32F10X_HD
  c include: ..\core;..\system\BEEP;..\system\DELAY;..\system\LED;..\system\KEY;..\system\SYS;..\system\USART;..\system\EXTI;..\system\TIMER;..\system\RTC;..\system\ADC;..\system\DS18B20;..\system\BLE;..\system\ESP8266;..\system\WDG;..\system\OLED;..\obj;..\system\74HC595;..\system\BIT_WHILE;..\system;..\FWlib\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group core
    ../core/: core_cm3.c system_stm32f10x.c startup_stm32f10x_hd.s
  group system
    ../system/BEEP/: beep.c
    ../system/DELAY/: delay.c
    ../system/LED/: led.c
    ../system/KEY/: key.c
    ../system/SYS/: sys.c
    ../system/USART/: usart.c
    ../system/EXTI/: exti.c
    ../system/TIMER/: timer.c
    ../system/RTC/: rtc.c
    ../system/ADC/: adc.c
    ../system/DS18B20/: ds18b20.c
    ../system/BLE/: ble.c
    ../system/ESP8266/: esp8266.c
    ../system/WDG/: wdg.c
    ../system/OLED/: oled.c
    ../system/74HC595/: 74hc595.c
    ../system/BIT_WHILE/: bit_while.c
    ../system/: hanzi.c
  group user
    ./: main.c
  group FWLIB
    ../FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
